# Keil uVision project T3wind.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F126 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: T3_4AO_REV30 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: serial.c T3_IO.c goalflash.c pic.c Range.c flash_info.c
